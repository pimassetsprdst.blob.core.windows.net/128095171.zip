Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-10-25T12:18:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160720_1515(x64) - Exporter 17.0.501.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 25 12:18:08 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{8BEFD6B7-D9DE-4BD6-A1B9-B8FF23B95799}\ifc * Database version: 5507 * Database creation date: Thu Oct 25 12:18:06 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Oct 25 12:18:07 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 25 12:18:07 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcDistributionControlElement: TSM-U.2.1-CG, E_Control Unit_MEPcontent_ABB_Tacteo_Room Numbers and Corridor Sensors_INT-EN:TSM-U.2.1-CG:1302350
In: V00
Type - Material: Color RGB 249-249-249, Color RGB 068-137-205, Color RGB 155-155-155, Color RGB 111-180-041, Color RGB 223-053-020
Type - Dimensions - Depth: 9 mm; Height: 157 mm; Rotation U-Axis Correction: 90 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 0 deg; Width: 86 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Identity Data - Article Type: TSM/U.2.1-CG; Base Family Version: 11.19; Category: EL_BUSSYSTEM_WITH_ADDRESS; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: TSM/U.2.1-CG Ro out sen/ca re/RoNr V; EMCS Version: 4.0; ETIM Article Class: EC000782; Family Version: 11.20; Manufacturer: ABB; Manufacturer URL: https://new.abb.com/products/2CKA006300A1555; MEPcontent Class: CONTROL_UNIT; Model: TSM/U.2.1-CG; OmniClass Number: 23.60.50.00; OmniClass Title: General Purpose Controls; Revit Version: 2017; Type Name: TSM-U.2.1-CG; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Bell: Color RGB 068-137-205; Body: Color RGB 249-249-249; Card: Color RGB 068-137-205; Logo: Color RGB 155-155-155; Privacy: Color RGB 223-053-020; Service: Color RGB 111-180-041
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Security Devices; Anti-Theft: 2; Card Visibility: yes; Family Name: E_Control Unit_MEPcontent_ABB_Tacteo_Room Numbers and Corridor Sensors_INT-EN; Mid logo: 18 mm; Safe Height: 156 mm; Safe Width: 85 mm
Type - Text - Article Description: TSM/U.2.1-CG Ro out sen/ca re/RoNr V; GTIN: 4011395230909; Manufacturer Art. No.: 2CKA006300A1555; Product Line: KNX - User Operation - tacteo - Room Numbers and Corridor Sensors
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.0390687 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000188024 m3
Identity Data - Design Option: Main Model; Mark: 1
Other - Anti-theft Protection: no; Anti-theft Protection 0.1: no; Family: E_Control Unit_MEPcontent_ABB_Tacteo_Room Numbers and Corridor Sensors_INT-EN: TSM-U.2.1-CG; Family and Type: E_Control Unit_MEPcontent_ABB_Tacteo_Room Numbers and Corridor Sensors_INT-EN: TSM-U.2.1-CG; Type: E_Control Unit_MEPcontent_ABB_Tacteo_Room Numbers and Corridor Sensors_INT-EN: TSM-U.2.1-CG; Type Id: E_Control Unit_MEPcontent_ABB_Tacteo_Room Numbers and Corridor Sensors_INT-EN: TSM-U.2.1-CG
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Anti-Theft Protection: no
